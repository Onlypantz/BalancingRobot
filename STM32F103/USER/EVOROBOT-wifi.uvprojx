# Keil uVision project EVOROBOT-wifi.uvprojx, settings and files
target MPU6050_TEST (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EVOROBOT-WIFIFIX +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_M,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\I2C_Hard;..\HARDWARE\MPU6050;..\HARDWARE\IIC;..\HARDWARE\OSC;..\HARDWARE\CONTROL;..\HARDWARE\SERVO;..\HARDWARE\NETWORK;..\HARDWARE\defines
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c main.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/MPU6050/: MPU6050.c
    ../HARDWARE/OSC/: osc.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/NETWORK/: network.c
    ../HARDWARE/I2C_Hard/: I2C_Hard.c
    ../HARDWARE/defines/: globals.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_tim.c
  group README
    ../: README.TXT
